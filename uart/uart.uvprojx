# Keil uVision project uart.uvprojx, settings and files
target UART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: ..\uart;.\STM32F4xx_StdPeriph_Driver\inc;.\cmsis
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c system_timetick.c main_official.c
  group STM32F407
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_gpio.c misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_spi.c
    D:/HK201/HTDKN_Ref/ref/Demos/ES_Exam2_UART/ES_Exam2_UART/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_i2c.c
software components: CMSIS:CORE 5.1.1
